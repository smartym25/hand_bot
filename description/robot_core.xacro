Commit message: Update robot_core.xacro

File: description/robot_core.xacro (robot description, xacro)
@@ -28,5 +28,3 @@
         </visual>
    </link>
-   <joint name="thumb_cmc_joint" type="revolute">
-    </joint>
 </robot>
